#include "hexagram.h"
#include "ganzhi.h"   // 地支名 / 地支五行 / 五行名 表（与历法层共用一份）

#include <stdio.h>    // snprintf：拼接纳甲干支
#include <string.h>   // strcmp：五行名 / 地支名 / 六亲名比较

// 由原项目 src/hexagram.cpp 机械移植（C++ 引用 -> 指针），数据表逐字保留。

// ===== 八卦基础数据（索引: 0乾1兑2离3震4巽5坎6艮7坤）=====
const uint8_t TRIGRAM_LINES[8][3] = {
  {1,1,1},{1,1,0},{1,0,1},{1,0,0},
  {0,1,1},{0,1,0},{0,0,1},{0,0,0},
};

// ===== 六十四卦名表 [上卦][下卦] =====
const char HEX_NAME[8][8][16] = {
  {"乾为天","天泽履","天火同人","天雷无妄","天风姤","天水讼","天山遁","天地否"},
  {"泽天夬","兑为泽","泽火革","泽雷随","泽风大过","泽水困","泽山咸","泽地萃"},
  {"火天大有","火泽睽","离为火","火雷噬嗑","火风鼎","火水未济","火山旅","火地晋"},
  {"雷天大壮","雷泽归妹","雷火丰","震为雷","雷风恒","雷水解","雷山小过","雷地豫"},
  {"风天小畜","风泽中孚","风火家人","风雷益","巽为风","风水涣","风山渐","风地观"},
  {"水天需","水泽节","水火既济","水雷屯","水风井","坎为水","水山蹇","水地比"},
  {"山天大畜","山泽损","山火贲","山雷颐","山风蛊","山水蒙","艮为山","山地剥"},
  {"地天泰","地泽临","地火明夷","地雷复","地风升","地水师","地山谦","坤为地"},
};

// ===== 六十四卦卦辞 [上卦][下卦] =====
const char HEX_JUDGE[8][8][24] = {
  {"元亨利贞","履虎尾不咥人","同人于野亨","无妄元亨利贞","女壮勿用取女","有孚窒惕","遯亨小利贞","否之匪人"},
  {"扬于王庭","亨","孚乃利用禴","元亨利贞","栋桡","亨贞大人吉","亨利贞","亨"},
  {"元亨","小事吉","贞吉","噬嗑亨利用狱","元吉亨","亨","旅贞吉","昼日三接"},
  {"利贞","征凶","宜日中","亨","亨","利西南","可小事不可大事","利行师"},
  {"亨","豚鱼吉","利女贞","利有攸往","小亨","亨王假有庙","女归吉","盥而不荐"},
  {"有孚","亨","亨小利贞","元亨利贞","改邑不改井","习坎有孚","利西南","吉"},
  {"利贞","有孚无吉","贲亨","贞吉","元亨","亨","艮其背","剥不利有攸往"},
  {"小往大来吉","元亨利贞","利艰贞","亨","升元亨","贞丈人吉","亨","元亨"},
};

// ===== 爻辞数据 [卦索引(上*8+下)][爻位0..5] =====
// LINE_JUDGES[idx][lineIdx] 其中 idx = upper*8 + lower, lineIdx 0=初 5=上
// 保留 __占位__ 表示该爻辞精简版无需展示（解卦只展示动爻爻辞）
static const char* LINE_JUDGES[64][6] = {
  // 0 乾为天
  {"潜龙勿用","见龙在田","终日乾乾","或跃在渊","飞龙在天","亢龙有悔"},
  // 1 天泽履
  {"素履往无咎","履道坦坦","跛能履","履虎尾愬愬","夬履贞厉","视履考祥"},
  // 2 天火同人
  {"同人于门","同人于宗","伏戎于莽","乘其墉弗克攻","同人先号咷","同人于郊"},
  // 3 天雷无妄
  {"无妄往吉","不耕获不菑畲","无妄之灾","可贞无咎","无妄之疾","无妄行有眚"},
  // 4 天风姤
  {"系于金柅","包有鱼","臀无肤","包无鱼","以杞包瓜","姤其角"},
  // 5 天水讼
  {"不永所事","不克讼","食旧德","不克讼复即命","讼元吉","或锡之鞶带"},
  // 6 天山遁
  {"遁尾厉","执之用黄牛","系遁有疾","好遁君子吉","嘉遁贞吉","肥遁无不利"},
  // 7 天地否
  {"拔茅茹以其汇","包承小人吉","包羞","有命无咎","休否大人吉","倾否先否后喜"},
  // 8 泽天夬
  {"壮于前趾","惕号莫夜","壮于頄","臀无肤","苋陆夬夬","无号终有凶"},
  // 9 兑为泽
  {"和兑吉","孚兑吉","来兑凶","商兑未宁","孚于剥","引兑"},
  // 10 泽火革
  {"巩用黄牛","巳日乃革之","征凶贞厉","改命吉","大人虎变","君子豹变"},
  // 11 泽雷随
  {"官有渝","系小子","系丈夫","随有获","孚于嘉","拘系之乃从维之"},
  // 12 泽风大过
  {"藉用白茅","枯杨生稊","栋桡凶","栋隆吉","枯杨生华","过涉灭顶"},
  // 13 泽水困
  {"臀困于株木","困于酒食","困于石","来徐徐","劓刖","困于葛藟"},
  // 14 泽山咸
  {"咸其拇","咸其腓","咸其股","贞吉悔亡","咸其脢","咸其辅颊舌"},
  // 15 泽地萃
  {"有孚不终","引吉无咎","萃如嗟如","大吉无咎","萃有位","赍咨涕洟"},
  // 16 火天大有
  {"无交害","大车以载","公用亨于天子","匪其彭","厥孚交如","自天祐之"},
  // 17 火泽睽
  {"悔亡丧马","遇主于巷","见舆曳","睽孤","悔亡厥宗噬肤","睽孤豕负涂"},
  // 18 离为火
  {"履错然敬之","黄离元吉","日昃之离","突如其来如","出涕沱若","王用出征"},
  // 19 火雷噬嗑
  {"屦校灭趾","噬肤灭鼻","噬腊肉遇毒","噬干胏得金矢","噬干肉得黄金","何校灭耳"},
  // 20 火风鼎
  {"鼎颠趾","鼎有实","鼎耳革","鼎折足","鼎黄耳金铉","鼎玉铉"},
  // 21 火水未济
  {"濡其尾","曳其轮","未济征凶","贞吉悔亡","贞吉无悔","有孚于饮酒"},
  // 22 火山旅
  {"旅琐琐","旅即次","旅焚其次","旅于处","射雉一矢亡","鸟焚其巢"},
  // 23 火地晋
  {"晋如摧如","晋如愁如","众允","晋如鼫鼠","悔亡失得","晋其角"},
  // 24 雷天大壮
  {"壮于趾","贞吉","小人用壮","藩决不羸","丧羊于易","羝羊触藩"},
  // 25 雷泽归妹
  {"归妹以娣","眇能视","归妹以须","归妹愆期","帝乙归妹","女承筐无实"},
  // 26 雷火丰
  {"遇其配主","丰其蔀","丰其沛","丰其蔀日中见斗","来章有庆誉","丰其屋"},
  // 27 震为雷
  {"震来虩虩","震来厉","震苏苏","震遂泥","震往来厉","震索索"},
  // 28 雷风恒
  {"浚恒贞凶","悔亡","不恒其德","田无禽","恒其德贞","振恒凶"},
  // 29 雷水解
  {"无咎","田获三狐","负且乘","解而拇","君子维有解","公用射隼"},
  // 30 雷山小过
  {"飞鸟以凶","过其祖","弗过防之","无咎弗过遇之","密云不雨","弗遇过之"},
  // 31 雷地豫
  {"鸣豫凶","介于石","盱豫迟","由豫大有得","贞疾恒不死","冥豫"},
  // 32 风天小畜
  {"复自道","牵复","舆说辐","有孚血去惕出","有孚挛如","既雨既处"},
  // 33 风泽中孚
  {"虞吉有他不燕","鸣鹤在阴","得敌","月几望","有孚挛如","翰音登于天"},
  // 34 风火家人
  {"闲有家","无攸遂","家人嗃嗃","富家大吉","王假有家","有孚威如"},
  // 35 风雷益
  {"利用为大作","或益之十朋龟","益之用凶事","中行告公从","有孚惠心","莫益之"},
  // 36 巽为风
  {"进退利武人之贞","巽在床下","频巽吝","悔亡田获三品","贞吉悔亡","巽在床下"},
  // 37 风水涣
  {"用拯马壮","涣奔其机","涣其躬","涣其群","涣汗其大号","涣其血"},
  // 38 风山渐
  {"鸿渐于干","鸿渐于磐","鸿渐于陆","鸿渐于木","鸿渐于陵","鸿渐于逵"},
  // 39 风地观
  {"童观","窥观利女贞","观我生进退","观国之光","观我生","观其生"},
  // 40 水天需
  {"需于郊","需于沙","需于泥","需于血","需于酒食","入于穴"},
  // 41 水泽节
  {"不出户庭","不出门庭","不节若","安节亨","甘节吉","苦节贞凶"},
  // 42 水火既济
  {"曳其轮","妇丧其茀","高宗伐鬼方","繻有衣袽","东邻杀牛","濡其首"},
  // 43 水雷屯
  {"磐桓","屯如邅如","即鹿无虞","乘马班如","屯其膏","泣血涟如"},
  // 44 水风井
  {"井泥不食","井谷射鲋","井渫不食","井甃无咎","井冽寒泉","井收勿幕"},
  // 45 坎为水
  {"习坎入于坎","坎有险","来之坎坎","樽酒簋贰","坎不盈","系用徽纆"},
  // 46 水山蹇
  {"往蹇来誉","王臣蹇蹇","往蹇来反","往蹇来连","大蹇朋来","往蹇来硕吉"},
  // 47 水地比
  {"有孚比之","比之自内","比之匪人","外比之","显比","比之无首"},
  // 48 山天大畜
  {"有厉利已","舆说輹","良马逐","童牛之牿","豮豕之牙","何天之衢亨"},
  // 49 山泽损
  {"已事遄往","利贞征凶","三人行损一人","损其疾","或益之十朋龟","弗损益之"},
  // 50 山火贲
  {"贲其趾","贲其须","贲如濡如","贲如皤如","贲于丘园","白贲无咎"},
  // 51 山雷颐
  {"舍尔灵龟","颠颐拂经","拂颐贞凶","颠颐吉","拂经居贞吉","由颐厉吉"},
  // 52 山风蛊
  {"干父之蛊","干母之蛊","干父之蛊小有悔","裕父之蛊","干父之蛊用誉","不事王侯"},
  // 53 山水蒙
  {"发蒙","包蒙纳妇","勿用取女","困蒙吝","童蒙吉","击蒙不利为寇"},
  // 54 艮为山
  {"艮其趾","艮其腓","艮其限","艮其身","艮其辅","敦艮吉"},
  // 55 山地剥
  {"剥床以足","剥床以辨","剥之无咎","剥床以肤","贯鱼以宫人宠","硕果不食"},
  // 56 地天泰
  {"拔茅茹以其汇","包荒用冯河","无平不陂","翩翩不富","帝乙归妹","城复于隍"},
  // 57 地泽临
  {"咸临贞吉","咸临吉无不利","甘临","至临无咎","知临大君之宜","敦临吉无咎"},
  // 58 地火明夷
  {"明夷于飞垂其翼","明夷夷于左股","明夷于南狩","入于左腹","箕子之明夷","不明晦"},
  // 59 地雷复
  {"不远复","休复吉","频复厉","中行独复","敦复无悔","迷复凶"},
  // 60 地风升
  {"允升大吉","孚乃利用禴","升虚邑","王用亨于岐山","贞吉升阶","冥升利于不息"},
  // 61 地水师
  {"师出以律","在师中吉","师或舆尸","师左次","田有禽","大君有命"},
  // 62 地山谦
  {"谦谦君子","鸣谦贞吉","劳谦君子","无不利撝谦","不富以其邻","鸣谦"},
  // 63 坤为地
  {"履霜坚冰至","直方大不习","含章可贞","括囊无咎","黄裳元吉","龙战于野"},
};

// ===== 爻辞白话 =====
// 与上面的 LINE_JUDGES 一一对应（64 卦 × 6 爻）。
//
// 为什么需要：爻辞是古文（"征凶贞厉""羝羊触藩"），普通人看不懂。
//
// 【关于"模板"】爻辞里能模板化的只有尾部的占断用语 —— 它们是一组固定词，
// 译法统一（这是本次翻译遵循的对照表）：
//     吉→吉利   元吉/大吉→大吉   凶→凶险   无咎→没有灾祸   悔亡→后悔消除
//     吝→有小的难堪   厉→有危险   勿用→先别出手   有孚→有诚信
//     利…→宜…   不利…→不宜…   贞→守正
//   但爻辞【主体是比喻】，384 条各不同（潜龙/含章/鸿渐于陆/羝羊触藩…），
//   没有模板可套，只能逐条译。下面就是逐条译的结果。
//
// 译法约定：
//   1. 只求"看懂大意"，不做学术译注；一条一句话。
//   2. 每条都 ≤12 个汉字 —— "断卦页"一行只放得下 12 字(224px/18px)，
//      超了会折行、把下面的内容顶下去。改文案时务必守住这条。
//   3. 原爻辞读起来像"预言吉凶"，白话里保留这层意思，但用词尽量说人话。
static const char* LINE_JUDGES_PLAIN[64][6] = {
  // 0 乾为天
  {"时机未到先别出手","开始露头可结交人","日夜勤勉别松劲",
   "可进可退看时机","正是大展宏图之时","太过极端必生悔"},
  // 1 天泽履
  {"本分做事就没灾","路平顺，走正道","实力不足勉强可行",
   "踩着虎尾谨慎则安","一意孤行守正也险","回头看，总结得失"},
  // 2 天火同人
  {"开门合作路子宽","只联络熟人圈子小","藏兵草中暗藏算计",
   "想争又罢手免争斗","先有争执后能和解","圈子在边缘未得志"},
  // 3 天雷无妄
  {"凭本心直行就吉","不付出就别贪得","无端飞来横祸",
   "守住本分就没事","意外小病不必强治","盲动会有灾祸"},
  // 4 天风姤
  {"用铜闸刹住别乱走","有实惠但别招外人","坐立不安进退两难",
   "好处丢了失去依靠","沉住气自有转机","走投无路难免有憾"},
  // 5 天水讼
  {"别把争执拖下去","争不过就退回家","守着老本分度日",
   "争不赢就回头安分","这场官司能大胜","赏来的也会被收回"},
  // 6 天山遁
  {"落在后面退有危险","决心坚定不可动摇","想退又牵挂很难受",
   "退得干脆就吉利","退得漂亮守正则吉","彻底抽身无所不利"},
  // 7 天地否
  {"同类相连一起行动","小人得势大人宜退","包藏羞愧不敢见人",
   "顺应时势就没事","闭塞将止大人得吉","先苦后甜局面翻转"},
  // 8 泽天夬
  {"急着往前容易吃亏","夜里也要提防报警","把怒气写在脸上",
   "坐立不安进退不便","除小人要果断","不警觉终有凶险"},
  // 9 兑为泽
  {"和气待人吉利","以诚相待吉利","一味讨好反招凶",
   "谈不拢心里不安","错信小人有危险","受人牵引随波逐流"},
  // 10 泽火革
  {"时机未熟先稳住","等时机到了再改","急着去改有凶险",
   "改弦更张就吉利","大人物改得光彩夺目","君子改得文采斐然"},
  // 11 泽雷随
  {"职务有变动","跟了小的丢了大的","跟对人放弃小的",
   "跟着有得但要守正","诚心向善吉利","用强力才能维系"},
  // 12 泽风大过
  {"小心谨慎虽过无妨","枯树发新芽有生机","房梁弯曲有凶险",
   "房梁高挺吉利","老树开花好看难久","涉水太深有灭顶灾"},
  // 13 泽水困
  {"坐在树桩上进退不得","被酒食所困享乐生困","被石头挡住进退两难",
   "来得慢，急也没用","受重创处境艰难","被藤缠住动不了"},
  // 14 泽山咸
  {"刚有点心动未行动","心动了但还不稳","跟着别人动会后悔",
   "守正则吉悔事可消","感受迟钝也无悔","光靠嘴皮子打动人"},
  // 15 泽地萃
  {"诚心不稳聚散无常","有人引荐就吉","聚在一起光叹气",
   "局面大好没有灾祸","在其位就能聚人","唉声叹气满脸泪"},
  // 16 火天大有
  {"不去招惹就没害","用大车装运堪重任","把成果献给上面",
   "不炫耀不过分","以诚相交众人信服","得天助，吉无不利"},
  // 17 火泽睽
  {"丢了别追自己会回","意外遇上贵人无灾","处处受阻很狼狈",
   "背离孤立无人相助","族人亲近可同往","疑心生暗鬼"},
  // 18 离为火
  {"脚步乱了要恭敬","守中正，大吉","日头偏西乐极生悲",
   "事来得突然难久","伤心流泪有忧患","该出手时就出手"},
  // 19 火雷噬嗑
  {"小惩大诫别再犯","咬得急了伤到自己","吃到硬骨头遇毒",
   "啃硬的反得好处","难啃的活有好报","罚重到伤耳，凶"},
  // 20 火风鼎
  {"鼎翻了脚先乱后定","鼎里有食但别独占","鼎耳坏了送不出去",
   "鼎断了腿事要败","扛得住重任稳当","贵重的抬举大吉"},
  // 21 火水未济
  {"尾巴沾湿别急着过","拉住车轮别冒进","事未成硬闯有凶",
   "守正则吉悔可消","守正则吉不用悔","安心饮酒乐天知命"},
  // 22 火山旅
  {"在外琐碎计较自找麻烦","客居有住处安稳","住处被烧失了依靠",
   "暂住在外心未安","损失一点终有得","巢被烧了先笑后哭"},
  // 23 火地晋
  {"上进受阻独守正","想上进却发愁","众人都认可可行",
   "像贪鼠一样钻营危","别计较得失无悔","进到角上只能整肃"},
  // 24 雷天大壮
  {"只脚上有劲缺思虑","守正就吉利","小人逞强君子不争",
   "篱笆破了冲得出去","粗心丢了羊别硬撑","公羊顶篱笆进退不得"},
  // 25 雷泽归妹
  {"以偏房身份出嫁位低","眼睛不好也能看勉强","等着出嫁反被耽误",
   "婚期拖延等人来","贵女下嫁名正言顺","筐里空无一物名不副实"},
  // 26 雷火丰
  {"遇上相配的人可共事","光明被遮住看不清","幔帐更厚更看不清",
   "正午见星昏暗至极","有才之人来助得誉","屋大而空孤立自封"},
  // 27 震为雷
  {"雷来心惊反而无灾","雷来势猛有危险","被震得心神不宁",
   "惊得陷进泥里动不了","雷来回滚处处危险","吓得腿软先凶后戒"},
  // 28 雷风恒
  {"求得太深太急反凶","后悔消除","没恒心反受羞辱",
   "打猎一无所得","守常不变各有吉凶","动个不停有凶险"},
  // 29 雷水解
  {"没有灾祸","除掉小人得实惠","背着东西还坐车招祸",
   "解开小牵扯才有真朋友","能解开纠结得众人信","一举射下凶隼能成功"},
  // 30 雷山小过
  {"鸟飞太高招凶险","越过祖父见祖母可","不去冒进要防人",
   "不冒进就无灾","云密却不下雨未成","错过太远招灾祸"},
  // 31 雷地豫
  {"得意张扬招凶","像石头般坚定守正吉","媚眼奉承迟了有悔",
   "顺势而为大有所得","久病不死得中位","沉迷享乐昏昧不明"},
  // 32 风天小畜
  {"自己回到正道上","被拉着一起回正道","车轮脱了辐走不动",
   "有诚心去忧惧","以诚相连众人相助","雨停了积德有得"},
  // 33 风泽中孚
  {"心定则吉他念则不安","鹤在深处鸣有回应","遇到对手自有主见",
   "月将圆失马也无咎","以诚相连无咎","高唱升天虚而不实"},
  // 34 风火家人
  {"治家要早立规矩","不擅作主张守中","管得太严虽悔无咎",
   "家道富足大吉","家长以身作则相交","诚信又有威严吉"},
  // 35 风雷益
  {"适合做大事","天赐厚利守正吉","借危机立信无咎",
   "行中道上层会同意","真心惠人不必问","没人帮你反被攻击"},
  // 36 巽为风
  {"犹疑时该像武人般决断","卑伏床下过分顺从","反复顺从反招困窘",
   "悔事消打猎丰收","守正则吉悔可消","过于卑顺失了本钱"},
  // 37 风水涣
  {"借壮马之力得救","奔向倚靠得以安稳","散掉私心无悔",
   "打散小圈子大吉","号令如汗出不返","散去忧患远离伤害"},
  // 38 风山渐
  {"鸿雁进到水边初受挫","鸿雁登上磐石安稳","鸿雁进到高地不宜进",
   "鸿雁落在树上危而不安","鸿雁登到山陵终得吉","鸿雁飞上高空可为范"},
  // 39 风地观
  {"像小孩看事太浅","见识狭窄守己为宜","看自己作为定进退",
   "看国之光华宜上进","自省其行君子无咎","观人亦被观宜自省"},
  // 40 水天需
  {"在郊外等待不急进","在沙地等待小有口舌","陷在泥里等招来寇",
   "身在险中顺其自然","以酒食自养守正吉","进了洞穴有客来助"},
  // 41 水泽节
  {"先不出门谨慎无咎","该出不出反招凶","不知节制就会叹气",
   "安心守节通顺","甘心节制吉利","过分苦守守正也凶"},
  // 42 水火既济
  {"拉住车轮缓一缓","丢了首饰别急着找","像高宗征伐三年才成",
   "备好破布防船漏水","隆重祭不如微薄诚","头都湿了危险"},
  // 43 水雷屯
  {"徘徊不前宜守正","艰难前行进退不易","追鹿没向导会迷路",
   "骑马徘徊不如求亲","施恩受阻宜小不宜大","哭到流血无路可走"},
  // 44 水风井
  {"井水浑了没人喝","井底射小鱼才不得用","井已淘好却没人用",
   "修好井壁没有灾","井水清冽可饮用","别盖上井诚则有吉"},
  // 45 坎为水
  {"险中有险越陷越深","只求小得别冒进","来来去去都是险",
   "薄礼诚心终无灾","坎没填满可无咎","被绳索捆住脱不了"},
  // 46 水山蹇
  {"去则难回则得誉","为公事奔波受难","去了会难回头为好",
   "去了会难回来联合","大难之中有朋友来","回头得力反有大吉"},
  // 47 水地比
  {"以诚相亲没有灾","从内心亲近守正吉","亲错了人要吃亏",
   "对外亲贤守正吉","光明相亲顺其自然","亲而无首不能善终"},
  // 48 山天大畜
  {"有危险宜停下来","车脱了轴走不了","策马前行宜防险",
   "小牛加木枷早防范","阉过的猪牙可驯服","大路通天通达无阻"},
  // 49 山泽损
  {"事毕速去合宜无咎","守正有利妄行有凶","三人同行必损一人",
   "去掉毛病反而有喜","天赐厚益大吉","不损而益守正得吉"},
  // 50 山火贲
  {"装饰脚趾弃车步行","装饰胡须随主而动","文饰光润守正则吉",
   "素装求婚终无咎","简朴少礼终得吉","朴素无饰没有灾"},
  // 51 山雷颐
  {"放着灵龟不用可惜","颠倒求养违背常理","违背养生之道凶",
   "虽求养于人也吉利","虽违常理守正可吉","由自己养人先危后吉"},
  // 52 山风蛊
  {"整治父辈败事有子","整治母辈旧弊宜守中","整治败事小有悔",
   "宽纵旧弊反更困顿","整治败事赢得赞誉","不侍王侯自守清高"},
  // 53 山水蒙
  {"开启蒙昧宜先用规矩","包容愚昧纳妇皆吉","别娶这样的女子",
   "困在蒙昧中可惜","像孩子般虚心吉","突破蒙昧不宜过凶"},
  // 54 艮为山
  {"停住脚止得及时","强止难止心不快","硬止腰身有危险",
   "止住自身不再妄动","稳住嘴说话有分寸","敦厚知止大吉"},
  // 55 山地剥
  {"从床脚开始剥落","剥到床身更近祸","该剥而剥反无咎",
   "剥到皮肉已经凶","成串鱼般有序无不利","硕果不摘君子得车"},
  // 56 地天泰
  {"同类相连一起行动","包容荒秽敢于涉险","有平有坎守正无咎",
   "轻浮失实靠邻相帮","贵女下嫁福泽自来","城墙倒回沟里泰极否来"},
  // 57 地泽临
  {"以感应下临守正吉","感应相临无所不利","甜言安抚难有好处",
   "亲身临察没有灾","明智临下合大国之宜","厚道临下吉利无咎"},
  // 58 地火明夷
  {"伤于飞垂下翅膀","左腿受伤需救助","南征狩猎除首恶",
   "深入其内可脱险","像箕子装傻避祸","由明入暗失则凶"},
  // 59 地雷复
  {"走不远就回头好","美善回归吉利","反复无常有危险",
   "行于中道独自回归","敦厚回归没有悔","迷失不知返有凶"},
  // 60 地风升
  {"受信任而升大吉","有诚心薄祭也可","升入空城无人阻拦",
   "像王者祭山顺利","守正而升拾级而上","盲目上升不知停止"},
  // 61 地水师
  {"出兵要有纪律","身在军中守中则吉","军队载尸而归凶",
   "退驻待命无咎","田中有禽宜持重","君王有命论功行赏"},
  // 62 地山谦
  {"谦而又谦可渡大川","谦名远播守正吉","有功劳而谦有终吉",
   "发挥谦德无所不利","不富也能得邻助","谦名在外宜先正己"},
  // 63 坤为地
  {"踩到霜寒冬将至","正直方大不必刻意","怀才不露守正可",
   "扎紧口袋谨慎无咎","居中守下大吉","龙斗于野两败俱伤"},
};

// ===== 卦象卦辞白话解读（据《周易》原文）=====
const char* getHexagramInterp(uint8_t upper, uint8_t lower) {
  uint8_t idx = upper * 8 + lower;
  switch (idx) {
    case  0: return "乾为天刚健自强";
    case  1: return "天泽履险中求胜";
    case  2: return "天火同人合作可成";
    case  3: return "天雷无妄守正免灾";
    case  4: return "天风姤相遇须防";
    case  5: return "天水讼退让和解";
    case  6: return "天山遁保存实力";
    case  7: return "天地否守静待机";
    case  8: return "泽天夬果断除小人";
    case  9: return "兑为泽以诚相待";
    case 10: return "泽火革破旧立新";
    case 11: return "泽雷随随势应变";
    case 12: return "泽风大过刚则易折";
    case 13: return "泽水困守正得解";
    case 14: return "泽山咸感应自然和";
    case 15: return "泽地萃集众力可为";
    case 16: return "火天大有富足防骄";
    case 17: return "火泽睽求同存异";
    case 18: return "离为火守中正明";
    case 19: return "火雷噬嗑除障得解";
    case 20: return "火风鼎革故鼎新";
    case 21: return "火水未济继续努力";
    case 22: return "火山旅漂泊宜守";
    case 23: return "火地晋顺势晋升";
    case 24: return "雷天大壮切忌逞强";
    case 25: return "雷泽归妹名正言顺";
    case 26: return "雷火丰盛极防衰";
    case 27: return "震为雷处变不惊";
    case 28: return "雷风恒守正恒久";
    case 29: return "雷水解把握时机";
    case 30: return "雷山小过收敛勿动";
    case 31: return "雷地豫安乐思危";
    case 32: return "风天小畜量弱待机";
    case 33: return "风泽中孚以诚感人";
    case 34: return "风火家人家和万事";
    case 35: return "风雷益利人利己";
    case 36: return "巽为风以柔克刚";
    case 37: return "风水涣聚心渡难关";
    case 38: return "风山渐欲速不达";
    case 39: return "风地观审时度势";
    case 40: return "水天需耐心待时机";
    case 41: return "水泽节制适度为宜";
    case 42: return "水火既济慎终如始";
    case 43: return "水雷屯开头难守正";
    case 44: return "水风井守恒不竭";
    case 45: return "坎为水沉着应险";
    case 46: return "水山蹇知难而进";
    case 47: return "水地比众志成城";
    case 48: return "山天大畜厚积薄发";
    case 49: return "山泽损先损后得";
    case 50: return "山火贲内重外华";
    case 51: return "山雷颐自食其力";
    case 52: return "山风蛊拨乱反正";
    case 53: return "山水蒙虚心受教";
    case 54: return "艮为山适可而止";
    case 55: return "山地剥待时运回转";
    case 56: return "地天泰万事亨通";
    case 57: return "地泽临以德服人";
    case 58: return "地火明夷晦暗待时";
    case 59: return "地雷复否极泰来";
    case 60: return "地风升积小成大";
    case 61: return "地水师纪律为先";
    case 62: return "地山谦满损谦益";
    case 63: return "坤为地厚德载物";
    default: return "";
  }
}

// ===== 类别针对性建议（据六爻断卦常法）=====
const char* getCategorySuggestion(uint8_t cat, bool yang) {
  // 8类别 × 阴阳 = 16条
  static const char* advice[8][2] = {
    {"事业宜积极进取把握机会", "事业宜稳守待时不宜冒进"},   // 0事业
    {"财运渐旺宜把握时机求财", "财运未显宜守财不宜投资"},   // 1财运
    {"感情顺遂宜主动推进关系", "感情需耐心经营不宜急躁"},   // 2感情
    {"身体渐佳宜积极调养治疗", "健康需静养不宜过度劳累"},   // 3健康
    {"学业可成宜专心备考进取", "学业遇阻宜夯实基础再进"},   // 4学业
    {"出行顺利宜早日动身成行", "出行不利宜推迟另选时机"},   // 5出行
    {"家运上升宜积极改善家居", "家运平稳宜守成不宜大动"},   // 6家宅
    {"所求之事转机将至可期待", "所求之事尚需等待勿急躁"},   // 7其他
  };
  return advice[cat][yang ? 0 : 1];
}

// ===== 动爻爻位含义（六爻常法：爻位象征事情所处阶段）=====
// 刻意写短：它要跟下面的五行走向、事由建议拼成同一句【断语】，
// 太长会把断语挤成三四行，屏幕上放不下。
static const char* LINE_POS_MEANING[6] = {
  "事在初萌",      // 初爻：事情刚起头
  "事入内局",      // 二爻：进入内卦之中
  "内卦至极",      // 三爻：内卦之极，最易生变
  "事近外局",      // 四爻：开始涉入外卦
  "居尊得中",      // 五爻：尊位得中，通常最吉
  "事已至末",      // 上爻：事情走到尽头
};

// ===== 动爻所在卦的五行走向（本卦 → 变卦）=====
// 同样写短，便于拼进断语句。
// 与爻位、事由三者彼此独立 → 断语句变体 = 6 × 5 × 2 = 60（单类别，全库 480）。
static const char* ELEM_RELATION_TEXT[5] = {
  "卦象比和",      // 0 比和
  "卦生变顺势",    // 1 本卦五行生变卦五行
  "变生卦得助",    // 2 变卦五行生本卦五行
  "卦克变可制",    // 3 本卦五行克变卦五行
  "变克卦受阻",    // 4 变卦五行克本卦五行（六爻里叫"回头克"）
};

// 五行索引按【相生顺序】排：木0 → 火1 → 土2 → 金3 → 水4
// 相生：(i+1)%5    相克：(i+2)%5
static int elem_index(const char* e) {
  if (!e) return -1;
  if (!strcmp(e, "木")) return 0;
  if (!strcmp(e, "火")) return 1;
  if (!strcmp(e, "土")) return 2;
  if (!strcmp(e, "金")) return 3;
  if (!strcmp(e, "水")) return 4;
  return -1;
}

// 返回 ELEM_RELATION_TEXT 的下标：0比和 1卦生变 2变生卦 3卦克变 4变克卦
static int five_elem_relation(const char* before, const char* after) {
  const int a = elem_index(before);
  const int b = elem_index(after);
  if (a < 0 || b < 0) return 0;          // 数据异常时不崩，退回"比和"
  if (a == b) return 0;
  if ((a + 1) % 5 == b) return 1;        // 我生它 → 顺势
  if ((b + 1) % 5 == a) return 2;        // 它生我 → 得助
  if ((a + 2) % 5 == b) return 3;        // 我克它 → 可制
  return 4;                              // 它克我 → 受阻
}

const char* getLinePosMeaning(uint8_t lineIdx) {
  if (lineIdx >= 6) return "";
  return LINE_POS_MEANING[lineIdx];
}

const char* getElemRelationText(uint8_t upper, uint8_t lower, uint8_t movingLine) {
  if (movingLine >= 6 || upper >= 8 || lower >= 8) return "";
  // 动爻在 0..2 → 动的是下卦；在 3..5 → 动的是上卦
  const char* before = (movingLine < 3) ? getTrigramElement(lower)
                                        : getTrigramElement(upper);
  uint8_t cu, cl;
  getChangedHexagram(upper, lower, movingLine, &cu, &cl);
  const char* after = (movingLine < 3) ? getTrigramElement(cl)
                                       : getTrigramElement(cu);
  return ELEM_RELATION_TEXT[five_elem_relation(before, after)];
}

// ===== 断语白话（爻位 / 五行走向）=====
// 见 hexagram.h 的说明：只描述"处在什么阶段、趋势顺不顺"，不下吉凶。
static const char* LINE_POS_PLAIN[6] = {
  "事情刚起头",    // 初：事情刚起头
  "正在往里走",    // 二：进入内卦之中
  "正处关节上",    // 三：内卦之极，最易生变
  "开始向外走",    // 四：开始涉入外卦
  "位置正得时",    // 五：尊位得中，通常最吉
  "已经到尾声",    // 上：事情走到尽头
};

static const char* ELEM_RELATION_PLAIN[5] = {
  "内外齐平",      // 0 比和
  "顺势可为",      // 1 卦生变
  "得外力助",      // 2 变生卦
  "主动权在己",    // 3 卦克变
  "中途有阻",      // 4 变克卦
};

const char* getLinePosPlain(uint8_t lineIdx) {
  if (lineIdx >= 6) return "";
  return LINE_POS_PLAIN[lineIdx];
}

const char* getElemRelationPlain(uint8_t upper, uint8_t lower, uint8_t movingLine) {
  if (movingLine >= 6 || upper >= 8 || lower >= 8) return "";
  const char* before = (movingLine < 3) ? getTrigramElement(lower)
                                        : getTrigramElement(upper);
  uint8_t cu, cl;
  getChangedHexagram(upper, lower, movingLine, &cu, &cl);
  const char* after = (movingLine < 3) ? getTrigramElement(cl)
                                       : getTrigramElement(cu);
  return ELEM_RELATION_PLAIN[five_elem_relation(before, after)];
}

// ===== 八卦辅助数据 =====
const char* TRIGRAM_NAMES[8] = {"乾","兑","离","震","巽","坎","艮","坤"};
const char* TRIGRAM_SYMBOLS[8] = {"☰","☱","☲","☳","☴","☵","☶","☷"};
const char* TRIGRAM_ELEMENTS[8] = {"金","金","火","木","木","水","土","土"};

// ===== 爻位名称（九=阳 六=阴）=====
static const char* LINE_POS_NAMES[6] = {"初","二","三","四","五","上"};
static const char YANG_STR[] = "九";
static const char YIN_STR[]  = "六";

// ===== 函数实现 =====

void getHexagram(uint8_t upperIdx, uint8_t lowerIdx, HexagramData *out) {
  out->name = HEX_NAME[upperIdx][lowerIdx];
  out->judgment = HEX_JUDGE[upperIdx][lowerIdx];
}

void generateHexagramFromDigits(const uint8_t digits[3],
                                 uint8_t *outUpper, uint8_t *outLower,
                                 uint8_t *outMovingLine) {
  uint8_t a = digits[0]; // 百位
  uint8_t b = digits[1]; // 十位
  uint8_t c = digits[2]; // 个位

  *outUpper = a % 8;
  if (*outUpper == 0) *outUpper = 7;

  *outLower = b % 8;
  if (*outLower == 0) *outLower = 7;

  uint8_t moving = c % 6;
  if (moving == 0) moving = 6;

  *outMovingLine = moving - 1; // 转为 0..5
}

void getChangedHexagram(uint8_t originalUpper, uint8_t originalLower,
                         uint8_t movingLine,
                         uint8_t *outUpper, uint8_t *outLower) {
  // 构建 6 爻
  uint8_t lines[6];
  for (int i = 0; i < 3; i++) {
    lines[i] = TRIGRAM_LINES[originalLower][i];   // 下卦初、二、三
    lines[i+3] = TRIGRAM_LINES[originalUpper][i]; // 上卦四、五、上
  }

  // 翻转动爻
  lines[movingLine] = 1 - lines[movingLine];

  // 拆回下卦（lines[0..2]）和上卦（lines[3..5]）
  *outLower = 7; // 默认坤
  *outUpper = 7;
  for (uint8_t i = 0; i < 8; i++) {
    bool matchLower = true, matchUpper = true;
    for (int j = 0; j < 3; j++) {
      if (TRIGRAM_LINES[i][j] != lines[j])   matchLower = false;
      if (TRIGRAM_LINES[i][j] != lines[j+3]) matchUpper = false;
    }
    if (matchLower) *outLower = i;
    if (matchUpper) *outUpper = i;
  }
}

const char* getLineJudgment(uint8_t upper, uint8_t lower, uint8_t lineIdx) {
  return LINE_JUDGES[upper * 8 + lower][lineIdx];
}

const char* getLineJudgmentPlain(uint8_t upper, uint8_t lower, uint8_t lineIdx) {
  if (lineIdx >= 6) return "";
  return LINE_JUDGES_PLAIN[upper * 8 + lower][lineIdx];
}

const char* getLineName(uint8_t lineIdx, bool isYang) {
  static char buf[8];
  const char* yinYang = isYang ? YANG_STR : YIN_STR;
  const char* pos = LINE_POS_NAMES[lineIdx];
  // 六爻命名: 初/上 + 九/六, 中间 九/六 + 二三西五
  // 例如: 初九, 九二, 九三, 九四, 九五, 上九
  if (lineIdx == 0 || lineIdx == 5) {
    // 初爻/上爻: 爻位在前
    buf[0]=pos[0]; buf[1]=pos[1]; buf[2]=pos[2];
    buf[3]=yinYang[0]; buf[4]=yinYang[1]; buf[5]=yinYang[2];
  } else {
    // 二至五爻: 九/六在前
    buf[0]=yinYang[0]; buf[1]=yinYang[1]; buf[2]=yinYang[2];
    buf[3]=pos[0]; buf[4]=pos[1]; buf[5]=pos[2];
  }
  buf[6] = 0;
  return buf;
}

const char* getTrigramName(uint8_t idx) {
  if (idx >= 8) return "";
  return TRIGRAM_NAMES[idx];
}

const char* getTrigramSymbol(uint8_t idx) {
  if (idx >= 8) return "";
  return TRIGRAM_SYMBOLS[idx];
}

const char* getTrigramElement(uint8_t idx) {
  if (idx >= 8) return "";
  return TRIGRAM_ELEMENTS[idx];
}

// ===== 事由类别数据 =====
uint8_t g_category = 0;

static const char* CATEGORY_NAMES[CATEGORY_COUNT] = {
  "事业前程", "财运求财", "感情姻缘", "健康平安",
  "学业考试", "出行迁移", "家宅运势", "其他所念",
};

static const char* CATEGORY_YONGSHEN[CATEGORY_COUNT] = {
  "官鬼", "妻财", "妻财+应爻", "官鬼+子孙",
  "父母+官鬼", "世爻+父母", "父母+世应", "世应综合",
};

const char* getCategoryName(uint8_t catIdx) {
  if (catIdx >= CATEGORY_COUNT) return "";
  return CATEGORY_NAMES[catIdx];
}

const char* getCategoryYongShen(uint8_t catIdx) {
  if (catIdx >= CATEGORY_COUNT) return "";
  return CATEGORY_YONGSHEN[catIdx];
}

// ===========================================================================
// 六爻【装卦】层
// ===========================================================================
// 全部按规则推导，无查表式的"写死答案"。数据只有两张：京房八宫卦序、八卦纳甲。

// ===== 京房八宫卦序 =====
// 每宫八卦，顺序固定为：本宫(八纯) / 一世 / 二世 / 三世 / 四世 / 五世 / 游魂 / 归魂
// 值 = 上卦索引 * 8 + 下卦索引（与 HEX_NAME 的 [上][下] 下标一致）
static const uint8_t PALACE_HEX[8][8] = {
  // 乾宫（金）：乾为天 天风姤 天山遁 天地否 风地观 山地剥 火地晋 火天大有
  { 0*8+0, 0*8+4, 0*8+6, 0*8+7, 4*8+7, 6*8+7, 2*8+7, 2*8+0 },
  // 兑宫（金）：兑为泽 泽水困 泽地萃 泽山咸 水山蹇 地山谦 雷山小过 雷泽归妹
  { 1*8+1, 1*8+5, 1*8+7, 1*8+6, 5*8+6, 7*8+6, 3*8+6, 3*8+1 },
  // 离宫（火）：离为火 火山旅 火风鼎 火水未济 山水蒙 风水涣 天水讼 天火同人
  { 2*8+2, 2*8+6, 2*8+4, 2*8+5, 6*8+5, 4*8+5, 0*8+5, 0*8+2 },
  // 震宫（木）：震为雷 雷地豫 雷水解 雷风恒 地风升 水风井 泽风大过 泽雷随
  { 3*8+3, 3*8+7, 3*8+5, 3*8+4, 7*8+4, 5*8+4, 1*8+4, 1*8+3 },
  // 巽宫（木）：巽为风 风天小畜 风火家人 风雷益 天雷无妄 火雷噬嗑 山雷颐 山风蛊
  { 4*8+4, 4*8+0, 4*8+2, 4*8+3, 0*8+3, 2*8+3, 6*8+3, 6*8+4 },
  // 坎宫（水）：坎为水 水泽节 水雷屯 水火既济 泽火革 雷火丰 地火明夷 地水师
  { 5*8+5, 5*8+1, 5*8+3, 5*8+2, 1*8+2, 3*8+2, 7*8+2, 7*8+5 },
  // 艮宫（土）：艮为山 山火贲 山天大畜 山泽损 火泽睽 天泽履 风泽中孚 风山渐
  { 6*8+6, 6*8+2, 6*8+0, 6*8+1, 2*8+1, 0*8+1, 4*8+1, 4*8+6 },
  // 坤宫（土）：坤为地 地雷复 地泽临 地天泰 雷天大壮 泽天夬 水天需 水地比
  { 7*8+7, 7*8+3, 7*8+1, 7*8+0, 3*8+0, 1*8+0, 5*8+0, 5*8+7 },
};

static const char* PALACE_NAME[8] = {
  "乾宫", "兑宫", "离宫", "震宫", "巽宫", "坎宫", "艮宫", "坤宫"
};

// ===== 世应位置（爻下标 0=初 … 5=上）=====
// 本宫世在六爻、一世世在初、二世在二、三世在三、四世在四、五世在五、
// 游魂世在四、归魂世在三；应爻与世爻相隔三位。
static const uint8_t SHI_POS[8]  = { 5, 0, 1, 2, 3, 4, 3, 2 };
static const uint8_t YING_POS[8] = { 2, 3, 4, 5, 0, 1, 0, 5 };

// ===== 八卦纳甲（京房纳甲）=====
// 天干：乾内甲外壬、坤内乙外癸，震庚、巽辛、坎戊、离己、艮丙、兑丁
static const char* NAJIA_GAN_IN[8]  = { "甲","丁","己","庚","辛","戊","丙","乙" };
static const char* NAJIA_GAN_OUT[8] = { "壬","丁","己","庚","辛","戊","丙","癸" };

// 地支：内卦三爻（初/二/三）—— 索引与八卦索引一致 0乾1兑2离3震4巽5坎6艮7坤
static const char* NAJIA_ZHI_IN[8][3] = {
  { "子","寅","辰" },  // 乾
  { "巳","卯","丑" },  // 兑
  { "卯","丑","亥" },  // 离
  { "子","寅","辰" },  // 震
  { "丑","亥","酉" },  // 巽
  { "寅","辰","午" },  // 坎
  { "辰","午","申" },  // 艮
  { "未","巳","卯" },  // 坤
};

// 地支：外卦三爻（四/五/上）
static const char* NAJIA_ZHI_OUT[8][3] = {
  { "午","申","戌" },  // 乾
  { "亥","酉","未" },  // 兑
  { "酉","未","巳" },  // 离
  { "午","申","戌" },  // 震
  { "未","巳","卯" },  // 巽
  { "申","戌","子" },  // 坎
  { "戌","子","寅" },  // 艮
  { "丑","亥","酉" },  // 坤
};

// 地支名（GZ_ZHI）、地支五行（GZ_ZHI_WUXING）、五行名（GZ_WUXING）
// 三张表由历法层 ganzhi.c 提供 —— 装卦与历法必须共用同一份，
// 否则两处各写一份，早晚会对不上。
static const char* LIUQIN_NAME[LIUQIN_COUNT] = {
  "兄弟","父母","子孙","妻财","官鬼"
};

static int zhi_index_of(const char* z) {
  if (!z) return -1;
  for (int i = 0; i < 12; i++) if (!strcmp(GZ_ZHI[i], z)) return i;
  return -1;
}

static int wuxing_index_of(const char* w) {
  if (!w) return -1;
  for (int i = 0; i < 5; i++) if (!strcmp(GZ_WUXING[i], w)) return i;
  return -1;
}

// 六亲：以卦宫五行为"我"
//   生我者父母 / 我生者子孙 / 克我者官鬼 / 我克者妻财 / 同我者兄弟
static int liuqin_of(int palace_wx, int line_wx) {
  if (line_wx == palace_wx)           return LIUQIN_XIONGDI;   // 同我
  if ((line_wx + 1) % 5 == palace_wx) return LIUQIN_FUMU;      // 它生我
  if ((palace_wx + 1) % 5 == line_wx) return LIUQIN_ZISUN;     // 我生它
  if ((line_wx + 2) % 5 == palace_wx) return LIUQIN_GUANGUI;   // 它克我
  return LIUQIN_QICAI;                                         // 我克它
}

void getLiuyaoChart(uint8_t upper, uint8_t lower, uint8_t movingLine,
                    liuyao_chart_t* out)
{
  if (!out) return;
  memset(out, 0, sizeof(*out));
  if (upper >= 8 || lower >= 8 || movingLine >= 6) return;

  // 1) 定卦宫与宫内位次
  const uint8_t key = (uint8_t)(upper * 8 + lower);
  int palace = -1, slot = -1;
  for (int p = 0; p < 8 && palace < 0; p++) {
    for (int s = 0; s < 8; s++) {
      if (PALACE_HEX[p][s] == key) { palace = p; slot = s; break; }
    }
  }
  if (palace < 0) return;   // 理论不可达：64 卦必然落在某一宫

  out->palace        = (uint8_t)palace;
  out->palace_name   = PALACE_NAME[palace];
  out->palace_wuxing = getTrigramElement((uint8_t)palace);
  const int palace_wx = wuxing_index_of(out->palace_wuxing);

  // 2) 逐爻：纳甲 → 地支五行 → 六亲 → 阴阳 → 世应 → 动爻
  for (int i = 0; i < 6; i++) {
    const bool lower_half = (i < 3);
    const uint8_t tri = lower_half ? lower : upper;      // 该爻所属的卦
    const int     k   = lower_half ? i : (i - 3);        // 在该卦里的位次

    const char* gan = lower_half ? NAJIA_GAN_IN[tri] : NAJIA_GAN_OUT[tri];
    const char* zhi = lower_half ? NAJIA_ZHI_IN[tri][k] : NAJIA_ZHI_OUT[tri][k];

    snprintf(out->lines[i].ganzhi, sizeof(out->lines[i].ganzhi), "%s%s", gan, zhi);

    const int zi = zhi_index_of(zhi);
    const int wx = (zi >= 0) ? (int)GZ_ZHI_WUXING[zi] : 0;

    out->lines[i].wuxing    = GZ_WUXING[wx];
    out->lines[i].liuqin    = LIUQIN_NAME[liuqin_of(palace_wx, wx)];
    out->lines[i].is_yang   = TRIGRAM_LINES[tri][k] != 0;
    out->lines[i].is_moving = (i == (int)movingLine);
    out->lines[i].shiying   = (i == SHI_POS[slot])  ? 1
                            : (i == YING_POS[slot]) ? 2 : 0;
  }
}

// 各事由的主用神（取 app 原有 CATEGORY_YONGSHEN 的第一项）；-1 = 以世爻为用
static const int CATEGORY_YONGSHEN_QIN[CATEGORY_COUNT] = {
  LIUQIN_GUANGUI,   // 事业前程：功名官运以官鬼为用
  LIUQIN_QICAI,     // 财运求财：妻财
  LIUQIN_QICAI,     // 感情姻缘：妻财（男占婚）
  LIUQIN_GUANGUI,   // 健康平安：疾病以官鬼为用
  LIUQIN_FUMU,      // 学业考试：文书以父母为用
  LIUQIN_FUMU,      // 出行迁移：车马行李以父母为用
  LIUQIN_FUMU,      // 家宅运势：宅舍以父母为用
  -1,               // 其他所念：无特定用神，以世爻为用
};

int getYongShenLine(uint8_t catIdx, const liuyao_chart_t* chart)
{
  if (!chart || catIdx >= CATEGORY_COUNT) return -1;

  const int want = CATEGORY_YONGSHEN_QIN[catIdx];
  if (want >= 0) {
    const char* name = LIUQIN_NAME[want];
    // 同六亲可能出现多爻，取靠下（先出现）的一爻
    for (int i = 0; i < 6; i++) {
      if (chart->lines[i].liuqin && !strcmp(chart->lines[i].liuqin, name)) return i;
    }
    return -1;   // 六爻术语：用神不上卦，需另取伏神（本层未实现）
  }
  // 以世爻为用
  for (int i = 0; i < 6; i++) if (chart->lines[i].shiying == 1) return i;
  return -1;
}
